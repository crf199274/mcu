# Keil uVision project magic.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: magic
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ./: main.c
  group OLED
    ./: OLED.c IIC.c
  group DC_DC
    ./: DC_DC.c
  group Key
    ./: key.c
  group Adc
    ./: adc.c
  group Common
    ./: delay.c
