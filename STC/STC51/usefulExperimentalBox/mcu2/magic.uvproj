# Keil uVision project magic.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: magic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LCD;.\Delay;.\ADC
  group main
    ./main/: main.c
  group LCD
    ./LCD/: LCD.c lcd_init.c
  group Delay
    ./Delay/: delay.c
  group ADC
    ./ADC/: adc.c
