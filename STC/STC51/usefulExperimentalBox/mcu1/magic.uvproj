# Keil uVision project magic.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: magic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\functionSwitching;.\function1;.\LCD;.\Delay;.\ADC;.\function2;.\function3
  group main
    ./main/: main.c
  group functionSwitching
    ./functionSwitching/: functionSwitching.c
  group function1
    ./function1/: function1.c WS2812.c
  group function2
    ./function2/: function2.c
  group function3
    ./function3/: function3.c
  group LCD
    ./LCD/: LCD.c lcd_init.c
  group Delay
    ./Delay/: delay.c
  group adc
    ./ADC/: adc.c
