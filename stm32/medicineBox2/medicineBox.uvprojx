# Keil uVision project medicineBox.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: A +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10_MD
  c misc: --locale=english
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP;.\Public;.\APP\lcd;.\APP\sd;.\APP\sd\fatfs;.\APP\fingerprint;.\APP\electricityLebelJudge;.\APP\voiceBroadcast;.\APP\web\device\inc;.\APP\web\json;.\APP\web\MQTT;.\APP\web\onenet\inc;.\APP\web\espUsart;.\APP\stepper;.\APP\timeGet;.\APP\web\sevice
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c AllTaskInit.c
  group startup
    ./User/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Public
    ./Public/: stdelay.c
  group FATFS
    ./APP/sd/fatfs/: diskio.c ff.c
  group rgbTFT
    ./APP/lcd/: rgbTFT.c GUI.c
  group SD_Card
    ./APP/sd/: spi.c sd.c
  group fingerprint
    ./APP/fingerprint/: fingerprint.c
  group electricityLebelJudge
    ./APP/electricityLebelJudge/: medicineBoxBack.c medicineBoxPosition.c userKey.c userLed.c
  group voiceBroadcast
    ./APP/voiceBroadcast/: voiceBroadcast.c
  group mqtt
    ./APP/web/device/src/: esp8266.c
    ./APP/web/MQTT/: MqttKit.c
    ./APP/web/espUsart/: usart.c
    ./APP/web/sevice/: service.c
  group stepper
    ./APP/stepper/: 42motor.c
  group timeGet
    ./APP/timeGet/: tim_interrupt.c
