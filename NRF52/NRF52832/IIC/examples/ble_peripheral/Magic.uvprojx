# Keil uVision project Magic.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Magic +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c include: ..\..\drive;..\..\components;..\..\components\libraries\delay;..\..\modules\nrfx\hal;..\..\modules\nrfx;..\..\config\nrf52832\config;..\..\integration\nrfx;..\..\components\libraries\util;..\..\modules\nrfx\drivers;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\balloc;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\memobj;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\strerror;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\mdk;..\..\modules\nrfx\drivers\src\prs;..\..\components\libraries\uart;..\..\integration\nrfx\legacy;..\..\components\libraries\bsp;..\..\components\boards;..\..\components\libraries\fifo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  group main
    ./: main.c
    ../../config/nrf52832/config/: sdk_config.h
  group drive
    ../../drive/: uart.c led.c oled.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_twi.c
    ../../modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_twim.c nrfx_twi.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
